Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2025-03-25T17:13:31
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - IU alternativa 20.0.0.377
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Mar 25 17:13:31 2025 * Host: MichellyManno * Database: C:\Users\MICHEL~1\AppData\Local\Temp\c891db82-06c3-4b4e-86b4-e6425ea95dc9\f05c5a8a-0c92-44d2-9fc5-7445b940ec8e\ifc * Database version: 5507 * Database creation date: Tue Mar 25 17:13:30 2025 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Mar 25 17:13:30 2025 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Mar 25 17:13:30 2025 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome do projeto; Phase: Status do projeto

# IfcSite, Default
RefLatitude: -15, -52, 0, -120620; RefLongitude: -47, -55, 0, -114440; RefElevation: 0 mm
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuilding
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuildingStorey: Nível:Cabeça de 8 mm, Nível 1
LongName: Nível 1; Elevation: 0 mm
Restrições(Type) - Base da elevação: Ponto base do projeto
Outros(Type) - Categoria: Níveis; Nome da família: Nível
Cotas - Cálculo da altura: 0 mm
Dados de identidade - Andar da construção: yes; Estrutural: no; Nome: Nível 1
Outros - Categoria: Níveis; Família: Nível: Cabeça de 8 mm; Família e tipo: Nível: Cabeça de 8 mm; ID de tipo: Nível: Cabeça de 8 mm; Tipo: Nível: Cabeça de 8 mm
Restrições - Elevação: 0 mm
Dados de identidade(Type) - Nome do tipo: Cabeça de 8 mm
Gráficos(Type) - Cor: 0; Espessura da linha: 1; Padrão de linha: Centro (1); Símbolo: M_Cabeça do nível - Círculo: M_Cabeça do nível - Círculo; Símbolo no final 1 padrão: no; Símbolo no final 2 padrão: yes

# IfcFlowTerminal: 6761, Emenda_L_Trilho_Skaly_6761_6762_Nordecor:6761:328169
In: Nível 1
Type - Classification: D5020200 Lighting Equipment (Uniformat); Material: Metal - Alumínio - Branco
Type - Cotas - Comprimento 01: 112.3 mm; Comprimento 02: 112.4 mm
Type - Dados - Data de atualização: 20/03/2025; Versão: 1
Type - Dados de identidade - Código de montagem: D5020200; Contato do desenvolvedor: "contato@checkbim.com.br"; Contato do fabricante: comercial@nordecor.com.br; Descrição: Emenda “L” de sobrepor para parede para trilho SKALY acabamento branco; Descrição de montagem: Lighting Equipment; Desenvolvedor: "Check BIM"; Fabricante: Nordecor; Garantia: 2 anos; IP: 20; Localização: Camboriú-SC / Brasil; Modelo: 6761; Nome do tipo: 6761; Número OmniClass: 23.80.70.11; Tipo de imagem: Imagem raster: 6761.png; Título OmniClass: Luminaries for Internal Lighting; URL: https://nordecor.com.br; URL do desenvolvedor: https://checkbim.com.br/; URL do produto: https://nordecor.com.br/produto/emenda-l-p-parede-de-sobrepor-p-trilho-skaly/
Type - Gráficos - Simbologia: Imagem raster: 6761 2D.png
Type - Materiais e acabamentos - Emenda "L": Metal - Alumínio - Branco
Type - Outros - Categoria: Luminárias; Branco: yes; Nome da família: Emenda_L_Trilho_Skaly_6761_6762_Nordecor; Preto: no
Type - Restrições - Elevação-padrão: 1219.2 mm
Type - Visibilidade - 2D: yes; Posição 01: yes; Posição 02: no
Cotas - Área: 0.0114429 m2; Volume: 0.0000331801 m3
Dados de identidade - Marca: 1
Elétrico - Iluminação - Calcular coeficiente de utilização: no
Fase - Fase criada: Construção nova
Outros - Família: Emenda_L_Trilho_Skaly_6761_6762_Nordecor: 6761; Família e tipo: Emenda_L_Trilho_Skaly_6761_6762_Nordecor: 6761; ID de tipo: Emenda_L_Trilho_Skaly_6761_6762_Nordecor: 6761; Tipo: Emenda_L_Trilho_Skaly_6761_6762_Nordecor: 6761
Restrições - Elevação do nível: 0 mm; Hospedeiro: Nível : Nível 1; Nível: Nível: Nível 1; Nível de tabela: Nível: Nível 1
